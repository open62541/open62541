## tests/zephyr/eventloop/testcase.yaml
```yaml
tests:
  open62541.eventloop.wakeup:
    tags: eventloop
    platform_allow:
      - mps2/an385
```
